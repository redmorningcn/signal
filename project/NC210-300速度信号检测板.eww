<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\NC210-300&#x901F;&#x5eA6;&#x4Fe1;&#x53F7;&#x68C0;&#x6D4B;&#x677F;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


