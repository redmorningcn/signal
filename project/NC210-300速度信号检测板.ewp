# IAR project NC210-300速度信号检测板.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _STM32F10X_CL; DEBUG; STM32F103RC; STM32_FLASH_SIZE=256; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\source\evalboard\FWlib\inc; ..\source\evalboard\FWlib\CMSIS\CM3\CoreSupport; ..\source\evalboard\FWlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\source\app\config; ..\source\app\user; ..\source\uC-CPU\ARM-Cortex-M3\IAR; ..\source\uC-CPU; ..\source\bsp; ..\source\bsp\bsp_int; ..\source\uC-LIB; ..\source\bsp\OS\uCOS-III; ..\source\uC-OS-III\Source; ..\source\uC-CPU\ARM-Cortex-M3\IAR; ..\source\uC-OS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\source\bsp\driver; ..\source\app\app_wave_task; ..\source\OSAL\OS; ..\source\uc-mb\Source; ..\source\uc-mb\Cfg\Template; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NC210-300速度信号检测板.bin
  ILINK.IlinkOutputFile: NC210-400速度信号检测板.out
  ILINK.IlinkIcfFile: ..\source\evalboard\IAR\STM32_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../source/app/app_wave_task/: app_wave_task.c
    ../source/app/: main.c
  group app/config
    ../source/app/config/: app.h app_variable.c app_wave.h cpu_cfg.h includes.h lib_cfg.h os_cfg.h stm32f10x_conf.h
  group bsp/bsp_int
    ../source/bsp/bsp_int/: bsp.c bsp_int.c
  group bsp/driver
    ../source/bsp/driver/: bsp_adc.c bsp_boardID.c bsp_dac.c bsp_flash.c bsp_flash.h bsp_wave_detect.c bsp_wdt.c bsp_wdt.h
  group doc
    ../doc/: readme.txt
  group evalboard/FWLib/CMSIS
    ../source/evalboard/FWlib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../source/evalboard/FWlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group evalboard/FWLib/inc
    ../source/evalboard/FWlib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group evalboard/FWLib/src
    ../source/evalboard/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group evalboard/IAR
    ../source/evalboard/IAR/: cstartup.c STM32_Flash.icf
  group osal/source
    ../source/OSAL/OS/: osal.c osal.h osal_cpu.h osal_event.c osal_event.h osal_memory.c osal_memory.h osal_timer.c osal_timer.h
  group uc-mb/cfg
    ../source/uc-mb/Cfg/Template/: mb_cfg.h MB_DATA.C
  group uc-mb/os
    ../source/uc-mb/OS/uCOS-III/: MB_OS.C MB_OS.H
  group uc-mb/port
    ../source/uc-mb/Ports/STM32/STM32F103/IAR/: MB_BSP.C
  group uc-mb/source
    ../source/uc-mb/Source/: MB.C MB.h MB_DEF.H MB_UTIL.C MBM_CORE.C MBS_CORE.C
